Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\SUBS\KI-0001-U05.IFC
Time: 2026-05-01T10:16:37+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 28.91
PSet_Mass_Property - Area Measure: 2.4971834247302787; Mass Measure: 28.9114942461924862; Volume Measure: 0.0037066018264349

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 28.91
PSet_Mass_Property - Area Measure: 2.4971834247302787; Mass Measure: 28.9114942461924862; Volume Measure: 0.0037066018264349

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 28.91
PSet_Mass_Property - Area Measure: 2.4971834247302787; Mass Measure: 28.9114942461924862; Volume Measure: 0.0037066018264349

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (3)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | Author = RevCreatedBy | DESCRIPTION | GA | Number | OriginationDate = RevCreationDate | Project Name | Revision | WEIGHT
KI-0000-GS01 | J.S | KI-0000-GS01 | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01 | 0.90
SHEET^KI-0001-U05 |  | SHEET^KI-0001-U05 |  |  |  |  |  | 27.11
KI-0000-GS01-1 | J.S | KI-0000-GS01 | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01 | 0.90

# IfcElementAssembly, KI-0001-U05
In: default BuildingStorey
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 28.91
PSet_Mass_Property - Area Measure: 2.4971834247302787; Mass Measure: 28.9114942461924862; Volume Measure: 0.0037066018264349
