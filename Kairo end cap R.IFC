Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\SUBS\KI-0001-LD-U03.IFC
Time: 2026-05-01T10:19:36+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 14.71
PSet_Mass_Property - Area Measure: 1.2826046082925329; Mass Measure: 14.7121070657238189; Volume Measure: 0.0018861675725287

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 14.71
PSet_Mass_Property - Area Measure: 1.2826046082925329; Mass Measure: 14.7121070657238189; Volume Measure: 0.0018861675725287

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 14.71
PSet_Mass_Property - Area Measure: 1.2826046082925329; Mass Measure: 14.7121070657238189; Volume Measure: 0.0018861675725287

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (4)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | WEIGHT
KI-0000-LD-GS01 | KI-0000-LD-GS01 | 1.05 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: L-GS01 - 300 - 600; OriginationDate: 06/08/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 06/08/2025; Revision: M01
KI-0000-LD-GS01-1 | KI-0000-LD-GS01 | 1.05 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: L-GS01 - 300 - 600; OriginationDate: 06/08/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 06/08/2025; Revision: M01
SHEET^KI-0001-LD-U03 | SHEET^KI-0001-LD-U03 | 2.65
Part1^KI-0001-LD-U03 | Part1^KI-0001-LD-U03 | 9.96 | SOLIDWORKS Custom Properties - Material: MILD STEEL

# IfcElementAssembly, KI-0001-LD-U03
In: default BuildingStorey
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 14.71
PSet_Mass_Property - Area Measure: 1.2826046082925329; Mass Measure: 14.7121070657238189; Volume Measure: 0.0018861675725287
