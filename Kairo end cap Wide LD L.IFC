Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\SUBS\KI-0001-LD-U05.IFC
Time: 2026-05-01T10:18:58+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 30.68
PSet_Mass_Property - Area Measure: 2.6576631769993302; Mass Measure: 30.6763645076278877; Volume Measure: 0.0039328672445677

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 30.68
PSet_Mass_Property - Area Measure: 2.6576631769993302; Mass Measure: 30.6763645076278877; Volume Measure: 0.0039328672445677

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 30.68
PSet_Mass_Property - Area Measure: 2.6576631769993302; Mass Measure: 30.6763645076278877; Volume Measure: 0.0039328672445677

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (4)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | WEIGHT
SHEET^KI-0001-LD-U05 | SHEET^KI-0001-LD-U05 | 7.17
KI-0000-LD-GS01 | KI-0000-LD-GS01 | 1.05 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: L-GS01 - 300 - 600; OriginationDate: 06/08/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 06/08/2025; Revision: M01
Part1^KI-0001-LD-U05 | Part1^KI-0001-LD-U05 | 21.41 | SOLIDWORKS Custom Properties - Material: MILD STEEL
KI-0000-LD-GS01-1 | KI-0000-LD-GS01 | 1.05 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: L-GS01 - 300 - 600; OriginationDate: 06/08/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 06/08/2025; Revision: M01

# IfcElementAssembly, KI-0001-LD-U05
In: default BuildingStorey
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 30.68
PSet_Mass_Property - Area Measure: 2.6576631769993302; Mass Measure: 30.6763645076278877; Volume Measure: 0.0039328672445677
